# Keil uVision project Template_Project.uvprojx, settings and files
target Template_Project (6190000::V6.19::ARMCLANG)
  device: M263KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.22
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M23") CLOCK(12000000) ESEL ELITTLE
  output: Template_Project
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3
  c include: ..\..\..\M261BSP-master\Library\CMSIS\Include;..\..\..\M261BSP-master\Library\Device\Nuvoton\M261\Include;..\..\..\M261BSP-master\Library\StdDriver\inc;..\..\UserDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M261.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../M261BSP-master/Library/Device/Nuvoton/M261/Source/: system_M261.c
    ../../../M261BSP-master/Library/Device/Nuvoton/M261/Source/ARM/: startup_M261.s
  group User
    ../: main.c
  group Library
    ../../../M261BSP-master/Library/StdDriver/src/: gpio.c retarget.c uart.c clk.c sys.c
  group User Driver
    ../../UserDriver/src/: template.c
